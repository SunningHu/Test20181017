# IAR project Backup of project.ewp, settings and files
configuration stm8l1526-eval (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\usr; ..\lib\inc; ..\lib\src; ..\Drive\inc; ..\Drive\src; ..\Function\inc; ..\Function\src; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Code_T2C3V100_20170510r1.hex
  ILINK.IlinkOutputFile: Code_T2C3V100_20170510r1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drive/inc
    ../Drive/inc/: DriveCom1.h DriveCom2.h DriveCom3.h DriveEEprom.h
  group Drive/src
    ../Drive/src/: DriveCom1.c DriveCom2.c DriveCom3.c DriveEEprom.c
  group Function/inc
    ../Function/inc/: FunctionDoData.h
  group Function/src
    ../Function/src/: FunctionDoData.c
  group lib
    ../lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group usr
    ../usr/: main.c stm8l15x_it.c
