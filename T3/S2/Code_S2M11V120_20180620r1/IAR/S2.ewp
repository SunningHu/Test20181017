# IAR project S2.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\Main; ..\User\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Hex_S2M1V103_20170816r1.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C6 STM8L151C6
  OBJCOPY.OOCOutputFile: S1.hex
  ILINK.IlinkOutputFile: S1.out
  group Doc
    ../Doc/: Log.txt
  group Libraries/STM8L15x_StdPeriph_Driver/inc
    ../Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_dma.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_iwdg.h stm8l15x_rst.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h
  group Libraries/STM8L15x_StdPeriph_Driver/src
    ../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_rst.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c
  group Main
    ../Main/: main.c stm8l15x_conf.h stm8l15x_it.c
    ../Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x_itc.h
  group User
    ../User/src/: battery.c
    ../Main/: stm8l15x_it.h
  group User/inc
    ../User/inc/: adcmd.h battery.h dac8552.h dodata.h domsg.h gui.h key.h lcd.h MathFunction.h measure.h TC.h timer.h usart1.h viewFrame.h viewMain.h viewMRSLH.h viewPrognm.h viewRemote.h viewRJTC.h viewRJView.h viewSRange.h viewSRSLH.h viewStep.h viewSweep.h
    ../../../test/time_base/code/usr/: pwm.h
  group User/src
    ../User/src/: adcmd.c dac8552.c dodata.c doMsg.c gui.c key.c lcd.c MathFunction.c measure.c pwm.c TC.c timer.c usart1.c viewFrame.c viewMain.c viewMRSLH.c viewPrognm.c viewRemote.c viewRJTC.c viewRJView.c viewSRange.c viewSRSLH.c viewStep.c viewSweep.c
